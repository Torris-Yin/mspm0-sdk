# Keil uVision project empty_msp32c031c6_nortos_keil.uvprojx, settings and files
target empty_msp32c031c6 (6160000::V6.16::ARMCLANG)
  device: MSP32C031C6 Texas Instruments
  output: empty_msp32c031c6 +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' empty_msp32c031c6.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSP32C031C6__
  c include: ../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  memory RVCT4: ROM 0x0 size 0x00008000
  memory RVCT9: RAM 0x20000000 size 0x00002000
  scatter file: .\msp32c031c6.sct
  group Source
    ../: empty_msp32c031c6.c empty_msp32c031c6.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_msp32c031cx_uvision.s
  group Driverlib
    ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0c1105_c1106/: driverlib.a
