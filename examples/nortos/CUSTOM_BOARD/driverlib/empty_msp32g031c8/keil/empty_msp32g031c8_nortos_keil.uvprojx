# Keil uVision project empty_msp32g031c8_nortos_keil.uvprojx, settings and files
target empty_msp32g031c8 (6160000::V6.16::ARMCLANG)
  device: MSP32G031C8 Texas Instruments
  output: empty_msp32g031c8 +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' empty_msp32g031c8.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSP32G031C8__
  c include: ../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  memory RVCT4: ROM 0x0 size 0x00010000
  memory RVCT9: RAM 0x20000000 size 0x00002000
  scatter file: .\msp32g031c8.sct
  group Source
    ../: empty_msp32g031c8.c empty_msp32g031c8.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_msp32g031cx_uvision.s
  group Driverlib
    ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0c1105_c1106/: driverlib.a
