# Keil uVision project empty_mspm0g3218_nortos_keil.uvprojx, settings and files
target empty_mspm0g3218 (6160000::V6.16::ARMCLANG)
  device: MSPM0G3218 Texas Instruments
  output: empty_mspm0g3218 +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' empty_mspm0g3218.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3218__
  c include: ../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  memory RVCT4: ROM 0x0 size 0x00040000
  memory RVCT9: RAM 0x20000000 size 0x00008000
  scatter file: .\mspm0g3218.sct
  group Source
    ../: empty_mspm0g3218.c empty_mspm0g3218.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g321x_uvision.s
  group Driverlib
    ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0gx218_gx207/: driverlib.a
